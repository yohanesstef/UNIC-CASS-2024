v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {t_h_bootstrap_switch.sym} 330 -160 0 0 {name=x1}
C {sky130_fd_pr/cap_mim_m3_1.sym} 540 -160 0 0 {name=C4 model=cap_mim_m3_1 W=80 L=62.5 MF=1 spiceprefix=X}
C {devices/lab_pin.sym} 540 -130 0 0 {name=p12 sig_type=std_logic lab=GND}
