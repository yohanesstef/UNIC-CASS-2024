v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -30 0 0 {name=l5 author="Yohanes Stefanus"}
C {sky130_fd_pr/cap_mim_m3_1.sym} 430 -220 0 0 {name=C1 model=cap_mim_m3_1 W=2 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 570 -220 0 0 {name=C2 model=cap_mim_m3_1 W=2 L=2 MF=1 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_1.sym} 710 -220 0 0 {name=C3 model=cap_mim_m3_1 W=2 L=2 MF=2 spiceprefix=X}
C {devices/lab_pin.sym} 710 -250 0 0 {name=p4 sig_type=std_logic lab=VPBT3}
C {devices/lab_pin.sym} 710 -190 0 0 {name=p5 sig_type=std_logic lab=VNBT3}
C {devices/lab_pin.sym} 570 -250 0 0 {name=p6 sig_type=std_logic lab=VPBT2}
C {devices/lab_pin.sym} 430 -250 0 0 {name=p7 sig_type=std_logic lab=VPBT1}
C {devices/lab_pin.sym} 430 -190 0 0 {name=p8 sig_type=std_logic lab=VNBT1}
C {devices/lab_pin.sym} 570 -190 0 0 {name=p1 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 310 -320 0 0 {name=p12 lab=VPBT1}
C {devices/ipin.sym} 310 -300 0 0 {name=p13 lab=VNBT1}
C {devices/ipin.sym} 310 -270 0 0 {name=p14 lab=VPBT2}
C {devices/ipin.sym} 310 -240 0 0 {name=p15 lab=VPBT3}
C {devices/ipin.sym} 310 -220 0 0 {name=p16 lab=VNBT3}
C {devices/ipin.sym} 310 -190 0 0 {name=p2 lab=CLKS}
