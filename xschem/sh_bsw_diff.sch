v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 -40 0 0 {name=l5 author="Yohanes Stefanus"}
C {sh_bsw-prelay.sym} 610 -340 0 0 {name=x1}
C {sh_bsw-prelay.sym} 610 -220 0 0 {name=x2}
C {devices/lab_pin.sym} 460 -380 0 0 {name=p1 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 460 -300 0 0 {name=p2 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 460 -260 0 0 {name=p3 sig_type=std_logic lab=VDDA}
C {devices/lab_pin.sym} 460 -180 0 0 {name=p4 sig_type=std_logic lab=VSSA}
C {devices/lab_pin.sym} 460 -360 0 0 {name=p5 sig_type=std_logic lab=CLKS}
C {devices/lab_pin.sym} 460 -240 0 0 {name=p6 sig_type=std_logic lab=CLKS}
C {devices/lab_pin.sym} 460 -340 0 0 {name=p7 sig_type=std_logic lab=CLKSB}
C {devices/lab_pin.sym} 460 -320 0 0 {name=p9 sig_type=std_logic lab=VIP}
C {devices/lab_pin.sym} 460 -200 0 0 {name=p10 sig_type=std_logic lab=VIN}
C {devices/lab_wire.sym} 760 -380 0 1 {name=p11 sig_type=std_logic lab=VCP}
C {devices/lab_wire.sym} 760 -260 0 1 {name=p12 sig_type=std_logic lab=VCN}
C {devices/ipin.sym} 330 -380 0 0 {name=p13 sig_type=std_logic lab=VDDA}
C {devices/ipin.sym} 330 -360 0 0 {name=p14 sig_type=std_logic lab=CLKS}
C {devices/ipin.sym} 330 -340 0 0 {name=p15 sig_type=std_logic lab=CLKSB}
C {devices/ipin.sym} 330 -320 0 0 {name=p16 sig_type=std_logic lab=VIP}
C {devices/ipin.sym} 330 -300 0 0 {name=p17 sig_type=std_logic lab=VIN}
C {devices/ipin.sym} 330 -280 0 0 {name=p18 sig_type=std_logic lab=VSSA}
C {devices/iopin.sym} 310 -260 0 0 {name=p19 sig_type=std_logic lab=VCP}
C {devices/iopin.sym} 310 -240 0 0 {name=p20 sig_type=std_logic lab=VCN}
C {devices/lab_pin.sym} 460 -220 0 0 {name=p8 sig_type=std_logic lab=CLKSB}
